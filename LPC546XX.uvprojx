# Keil uVision project LPC546XX.uvprojx, settings and files
target SeekFree_LPC546XX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54606J512BD100 NXP
  pack: NXP.LPC54606_DFP.12.0.0
  cpu: IRAM(0x04000000,0x8000) IRAM2(0x20000000,0x028000) IROM(0x40108000,0x4000) IROM2(0x00000000,0x080000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPC546XX
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\Drives\common;.\Drives\inc;.\seekfree;.\USER\inc;.\USER\_BALANCE\_MPU6050;.\USER\_OLEDMenu;.\USER\_SONIC;.\USER\_PID;.\USER\_BALANCE;.\USER\_CONTROL;.\USER\_ELECTRON;.\USER\_CAMERA;.\USER\_ELECTRON\_MCP41;.\USER\_UI;.\USER\_OLEDMenu;.\USER\_IMAGEPROCESS
  memory RVCT4: ROM 0x40108000 size 0x4000
  memory RVCT5: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x4000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x28000
  group startup
    ./CMSIS/: startup_LPC54606.s system_LPC54606.c system_LPC54606.h
  group drives_h
    ./Drives/inc/: LPC546XX_adc.h LPC546XX_ctimer.h LPC546XX_dma.h LPC546XX_eeprom.h LPC546XX_flexcomm.h LPC546XX_gint.h LPC546XX_gpio.h LPC546XX_iic.h LPC546XX_iocon.h LPC546XX_pint.h LPC546XX_pit.h LPC546XX_pll.h LPC546XX_sct.h LPC546XX_spi.h LPC546XX_systick.h LPC546XX_uart.h LPC546XX_mrt.h
  group drives_c
    ./Drives/src/: LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_eeprom.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c LPC546XX_mrt.c
    ./USER/_BALANCE/_MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group common
    ./Drives/common/: assert.c assert.h common.c common.h misc.c misc.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group user_h
    ./USER/inc/: isr.h LPC546XX_config.h PIN_CFG.h
    ./Drives/inc/: headfile.h
    ./USER/_BALANCE/_MPU6050/: SelfBuild_mpu6050.h SelfBuild_myiic.h
    ./USER/_PID/: SelfBuild_PID.h
    ./USER/_CONTROL/: SelfBuild_control.h
    ./USER/_ELECTRON/_MCP41/: SelfBuild_mcp41.h
    ./USER/_ELECTRON/: SelfBuild_correct_sensor.h SelfBuild_Electron_Calcu.h
    ./USER/_OLEDMenu/: SelfBuild_OLEDMenu.h
    ./USER/_IMAGEPROCESS/: ImageProcess.h
  group user_c
    ./USER/src/: isr.c main.c
    ./USER/_CONTROL/: SelfBuild_control.c
    ./USER/_BALANCE/_MPU6050/: SelfBuild_myiic.c SelfBuild_mpu6050.c dmpKey.h dmpmap.h
    ./USER/_PID/: SelfBuild_PID.c
    ./USER/_ELECTRON/: SelfBuild_correct_sensor.c SelfBuild_Electron_Calcu.c
    ./USER/_ELECTRON/_MCP41/: SelfBuild_mcp41.c
    ./USER/_OLEDMenu/: SelfBuild_OLEDMenu.c
    ./USER/_IMAGEPROCESS/: ImageProcess.c
  group seekfree
    ./seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h VCAN_computer.c VCAN_computer.h
